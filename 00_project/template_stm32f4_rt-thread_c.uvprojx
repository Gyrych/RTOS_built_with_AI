# Keil uVision project template_stm32f4_rt-thread_c.uvprojx, settings and files
target template_stm32f4_rt-thread-nano_c (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template_stm32f4_rt-thread_c
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\01_stm32f4_rt-thread_c;..\..\..\01_fwlib\01_stm32\05_stm32f4\01_V1.8.0\inc;..\..\..\02_rtos\01_rt_thread_nano\V3.1.5\include;..\..\..\02_rtos\01_rt_thread_nano\V3.1.5\include\libc;..\..\..\02_rtos\01_rt_thread_nano\V3.1.5\finsh;..\..\..\03_hal\05_stm32f4\hal_gpio;..\..\..\03_hal\05_stm32f4\hal_chip;..\..\..\03_hal\05_stm32f4\hal_can;..\..\..\03_hal\05_stm32f4\hal_timer;..\..\..\03_hal\05_stm32f4\hal_uart;..\..\..\04_osal;..\..\..\04_osal\01_rt-thread-nano;..\..\..\05_drv\drv_led;..\..\..\05_drv\drv_can_interface;..\..\..\05_drv\drv_pwm_timer_driven;..\..\..\05_drv\drv_stepmotor;..\..\..\05_drv\drv_motion_control_components;..\..\..\05_drv\drv_pump;..\..\..\05_drv\drv_valve;..\..\..\05_drv\drv_switching_sensor;..\..\..\05_drv\drv_fan;..\..\..\05_drv\drv_heat;..\..\..\05_drv\drv_pid;..\..\..\05_drv\drv_pid_self_tuning;..\..\..\05_drv\drv_probe;..\..\..\05_drv\drv_relay;..\..\..\05_drv\drv_simulate_iic;..\..\..\05_drv\drv_simulate_spi;..\..\..\05_drv\drv_uart_interface;..\..\..\05_drv\drv_pwm_pin;..\..\..\05_drv\drv_delay;..\..\..\06_sys\01_command_dispatcher\sys_double_list;..\..\..\06_sys\01_command_dispatcher\sys_cmd_regedit;..\..\..\06_sys\01_command_dispatcher\sys_cmd_scheduler;..\..\..\06_sys\01_command_dispatcher\sys_tasks;.\User;.\User\func\func_common;.\User\func\func_1;.\User\func\func_2;.\User\func\func_3;.\User\func\func_4;.\User\config\stm32f4\config;.\User\config\stm32f4\core;.\User\config\rt-thread_nano\oscfg;.\User\config\sys;.\User\config\drv
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --info stack
  group fwlib (stm32f4标准库 V1.8.0)
    ../../../01_fwlib/01_stm32/05_stm32f4/01_V1.8.0/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group rtos/kernel (rt-thread-nano V3.1.5)
    ../../../02_rtos/01_rt_thread_nano/V3.1.5/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtos/finsh (rt-thread-nano V3.1.5)
    ../../../02_rtos/01_rt_thread_nano/V3.1.5/finsh/: cmd.c msh.c shell.c finsh_port.c
  group hal (基于 stm32f4标准库 V1.8.0)
    ../../../03_hal/05_stm32f4/hal_gpio/: hal_gpio.c
    ../../../03_hal/05_stm32f4/hal_chip/: hal_chip.c
    ../../../03_hal/05_stm32f4/hal_can/: hal_can.c
    ../../../03_hal/05_stm32f4/hal_timer/: hal_timer.c
    ../../../03_hal/05_stm32f4/hal_uart/: hal_uart.c
  group osal (基于 rt-thread-nano V3.1.5)
    ../../../04_osal/01_rt-thread-nano/: osal.c
  group drv
    ../../../05_drv/drv_can_interface/: drv_can_interface.c
    ../../../05_drv/drv_motion_control_components/: drv_motion_control_components.c
    ../../../05_drv/drv_led/: drv_led.c
    ../../../05_drv/drv_pwm_timer_driven/: drv_pwm_timer_driven.c
    ../../../05_drv/drv_stepmotor/: drv_stepmotor.c
    ../../../05_drv/drv_switching_sensor/: drv_switching_sensor.c
    ../../../05_drv/drv_heat/: drv_heat.c
    ../../../05_drv/drv_pid/: drv_pid.c
    ../../../05_drv/drv_probe/: drv_probe.c
    ../../../05_drv/drv_relay/: drv_relay.c
    ../../../05_drv/drv_simulate_iic/: drv_simulate_iic.c
    ../../../05_drv/drv_simulate_spi/: drv_simulate_spi.c
    ../../../05_drv/drv_uart_interface/: drv_uart_interface.c
    ../../../05_drv/drv_pwm_pin/: drv_pwm_pin.c
    ../../../05_drv/drv_pump/: drv_pump.c
    ../../../05_drv/drv_valve/: drv_valve.c
    ../../../05_drv/drv_fan/: drv_fan.c
    ../../../05_drv/drv_pid_self_tuning/: drv_pid_self_tuning.c
    ../../../05_drv/drv_delay/: drv_delay.c
  group sys
    ../../../06_sys/01_command_dispatcher/sys_cmd_regedit/: sys_cmd_regedit.c
    ../../../06_sys/01_command_dispatcher/sys_cmd_scheduler/: sys_cmd_scheduler.c
    ../../../06_sys/01_command_dispatcher/sys_double_list/: sys_double_list.c
    ../../../06_sys/01_command_dispatcher/sys_tasks/: sys_tasks.c
  group user/func
    ./User/func/func_common/: func_common.c
    ./User/func/func_1/: func_1.c
    ./User/func/func_2/: func_2.c
    ./User/func/func_3/: func_3.c
    ./User/func/func_4/: func_4.c
  group user/chip_cfg
    ./User/config/stm32f4/core/: stm32f4xx_it.c system_stm32f4xx.c
    ./User/config/stm32f4/config/: stm32f4xx_conf.h
    ./User/config/stm32f4/core/mdk/: startup_stm32f40xx.s
  group user/os_cfg
    ./User/config/rt-thread_nano/oscfg/: board.c context_rvds.S cpuport.c rtconfig.h osal_config.h
  group user/sys_cfg
    ./User/config/sys/: sys_config.h
  group user/drv_cfg
    ./User/config/drv/: drv_can_interface_config.h
  group user
    ./User/: main.c
software components: CMSIS:CORE 4.3.0
